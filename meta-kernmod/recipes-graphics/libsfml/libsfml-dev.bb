DESCRIPTION = "Simple DirectMedia Layer is a cross-platform multimedia \
library designed to provide low level access to audio, keyboard, mouse, \
joystick, 3D hardware via OpenGL, and 2D video framebuffer."
HOMEPAGE = "http://www.libsdl.org"
LICENSE = "MIT"

SRC_URI = "http://www.libsdl.org/release/SDL2-${PV}.tar.gz"

